# Keil uVision project Project.uvprojx, settings and files
target PY32F071xB_Project (6220000::V6.22::ARMCLANG)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F071xB,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\Firmware\Drivers\CMSIS\Include;..\Firmware\Drivers\CMSIS\Device\PY32F071\Include;..\Firmware\Drivers\PY32F071_HAL_Driver\Inc;..\CherryUSB\common;..\CherryUSB\class\cdc;..\CherryUSB\class\hid;..\CherryUSB\core;..\Firmware\Drivers\PY32F071_HAL_Driver\Inc;..\CherryUSB_Port;..\Keyboard;..\WS2812
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f071xx.s
    ../Src/: system_py32f071.c
  group Application/User
    ../Src/: py32f071_hal_msp.c py32f071_it.c main.cpp
    ../Keyboard/: hid_keyboard.c
  group Drivers/PY32F071_HAL_Driver
    ../Firmware/Drivers/PY32F071_HAL_Driver/Src/: py32f071_hal.c py32f071_hal_adc.c py32f071_hal_adc_ex.c py32f071_hal_comp.c py32f071_hal_cortex.c py32f071_hal_crc.c py32f071_hal_ctc.c py32f071_hal_dac.c py32f071_hal_dac_ex.c py32f071_hal_div.c py32f071_hal_dma.c py32f071_hal_exti.c py32f071_hal_flash.c py32f071_hal_gpio.c py32f071_hal_i2c.c py32f071_hal_i2s.c py32f071_hal_irda.c py32f071_hal_iwdg.c py32f071_hal_lcd.c py32f071_hal_lptim.c py32f071_hal_opa.c py32f071_hal_opa_ex.c py32f071_hal_pwr.c py32f071_hal_rcc.c py32f071_hal_rcc_ex.c py32f071_hal_rtc.c py32f071_hal_rtc_ex.c py32f071_hal_smartcard.c py32f071_hal_spi.c py32f071_hal_tim.c py32f071_hal_tim_ex.c py32f071_hal_uart.c py32f071_hal_usart.c py32f071_hal_wwdg.c py32f071_ll_adc.c py32f071_ll_comp.c py32f071_ll_crc.c py32f071_ll_ctc.c py32f071_ll_dac.c py32f071_ll_dma.c py32f071_ll_exti.c py32f071_ll_gpio.c py32f071_ll_i2c.c py32f071_ll_lcd.c py32f071_ll_lptim.c py32f071_ll_pwr.c py32f071_ll_rcc.c py32f071_ll_rtc.c py32f071_ll_spi.c py32f071_ll_tim.c py32f071_ll_usart.c py32f071_ll_utils.c
  group CherryUSB
    ../CherryUSB/core/: usbd_core.c
    ../CherryUSB/class/cdc/: usbd_cdc.c
    ../CherryUSB/class/hid/: usbd_hid.c
    ../CherryUSB_Port/: usb_dc_py32.c
  group WS2812
    ../WS2812/: ws2812.cpp
  group Keyboard
    ../Keyboard/: KeyboardScan.cpp
software components: CMSIS:CORE 5.6.0
